# Keil uVision project teplomer.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.3
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: teplomer
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: blinkLED.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.2
